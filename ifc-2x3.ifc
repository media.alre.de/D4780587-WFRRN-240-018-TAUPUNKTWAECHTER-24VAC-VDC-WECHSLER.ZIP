Properties of the parts of a building model (IFC2X3)

# File
Description: Taupunktwächter, 24 VAC/VDC, Wechsler, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: D4780587, Taupunktwächter, 24 VAC/VDC, Wechsler
In: Raum
Description: Elektronischer Taupunktwächter mit Normschienenbefestigung zur Erfassung und Meldung des Taupunktes. Er verhindert bei korrekter Montage des Taupunktsensors (TPS 1, 2, 3) abtropfendes Kondenswasser von den gekühlten Teilen des Kühlkreislaufs. Hierzu wird ein an geeigneter Stelle am Kühlkreislauf befindlicher Taupunktsensor ausgewertet und bei Betauung ein potentialfreier Wechselkontakt umgeschaltet. Dieser Kontakt kann zur direkten Unterbrechung der Kühlung oder zur indirekten Unterbrechung der Kühlung durch Meldung an eine Gebäudeleittechnik genutzt werden. Kann der optimale Montageort nicht eindeutig festgelegt werden, besteht die Möglichkeit bis zu 5 Taupunktsensoren parallel an den Wächter anzuschließen. Die aktivierte Funktion „Kühlunterbrechung durch Taupunktauslösung“ wird durch eine rote Lampe am Gerät angezeigt. Der Schaltpunkt liegt fest bei ca. 98 % r.H.; Classification: EC011176 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: D4780587; ModelLabel: WFRRN-240.018; GlobalTradeItemNumber: 4050528027160; ProductURL: https://alre.de/produkt_D4780587
Pset_Specification - NominalLength: 0.086 m; NominalWidth: 0.0625 m; NominalDepth: 0.036 m; NetWeight: 0.076
Pset_ALRE_ETIM_Properties - Farbe: grau; Breite: 36; Höhe: 86; Tiefe: 62.5; RAL-Nummer: 7035; Explosionsgeschützt: no; Schutzart (IP): IP20; Max. Mediumtemperatur (Dauerbetrieb): 55; Max. Spannung der Kontakte: 48; Max. Kontaktbelastung: 10; Messbereich unterer Wert (relative Luftfeuchtigkeit): 98; Messbereich oberer Wert (relative Luftfeuchtigkeit): 98; Schaltdifferenz einstellbar: no; ETIM-Klasse: EC011176; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-D4780587.pdf
